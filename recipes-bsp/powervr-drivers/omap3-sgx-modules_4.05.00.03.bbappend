# why oh why 

TI_PLATFORM = "omap3630"
MODULESLOCATION="dc_omapfb3_linux"
