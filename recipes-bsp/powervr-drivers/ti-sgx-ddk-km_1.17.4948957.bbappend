FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-fix-Makefile-template.patch \
            file://0002-fix-to-new-get_user_pages.patch"
