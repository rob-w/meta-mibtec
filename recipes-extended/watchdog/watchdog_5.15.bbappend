FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
#SRC_URI += "file://watchdog.conf.patch"
