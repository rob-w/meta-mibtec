# yet again ?
export BINLOCATION = "${S}/gfx_rel_es3.x"

