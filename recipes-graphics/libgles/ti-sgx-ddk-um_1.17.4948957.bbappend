INITSCRIPT_PARAMS = "start 96 S ."
