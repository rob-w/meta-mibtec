FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://size.patch"
