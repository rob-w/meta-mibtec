FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://hack-backlight.patch"

