FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://interfaces"

