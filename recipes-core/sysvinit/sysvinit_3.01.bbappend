FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://rc"
SRC_URI += "file://rcS-default"
