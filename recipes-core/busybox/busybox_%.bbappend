FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
DEPENDS += "libtirpc"
#SRC_URI += "file://no_rpc.cfg"

