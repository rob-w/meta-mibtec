EXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}"
SRC_URI += "file://defconfig"

