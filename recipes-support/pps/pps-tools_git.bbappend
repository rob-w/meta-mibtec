SRCREV = "b3eae485a8c759d1ce1727076b2c287deb5f24e1"
SRC_URI = "git://github.com/redlab-i/pps-tools.git"
