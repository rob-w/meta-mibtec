FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://ntpdate.default \
            file://ntpdate"
